# Keil uVision project GreenHouseMonitoringSystem.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ARM7 (Little Endian) ARM
  cpu: CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: GreenHouseMonitoringSystem
  c flags: Optim=1
  group Source Group 1
    ./: ApplicationEntryPoint.c DisplayManager.c GSMManager.c StorageManager.c UpdateManager.c IOManager.c Constants.h DisplayManager.h GSMManager.h IOManager.h StorageManager.h UpdateManager.h
