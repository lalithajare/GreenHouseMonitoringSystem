# Keil uVision project GHES.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: GHES +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: Startup.s ApplicationEntryPoint.c Constants.c DisplayManager.c GSMManager.c IOManager.c StorageManager.c UpdateManager.c Constants.h DisplayManager.h GSMManager.h IOManager.h StorageManager.h UpdateManager.h
